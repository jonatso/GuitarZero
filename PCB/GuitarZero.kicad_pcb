# Repository jonatso/GuitarZero

File README.md:

## The idea

Our concept was a game inspired by Guitar Hero, where the player plays notes corresponding with notes ”falling down” a led matrix. Whether or not the player successfully plays the beat, determines which notes are actually being played. The player is meant to control the lead instrument, resulting in this instrument not being played whenever the player fails to hit a note. The backing instruments are always played. From the menu, the player has the option to select between a handful of songs of varying difficulty.

## Technical Summary

The MCU controls the song flow, input from the user and the visual output. The MCU sends data over SPI to the FPGA containing the required information about which notes the FPGA should play. The FPGA receives this data, and generates an audio signal using a set of pre-made instruments which contain one or more voices. This signal is further passed on to a DAC using I2S. Finally, the DAC outputs the audio to the onboard speaker or the audio jack.

## KiCad design PCB/GuitarZero.kicad_pcb

File PCB/README.md:

# TDT4295

Open GuitarZero.kicad_pro in kicad to open the projetc. Then click schematic ceditor to view the schematic.
Seperate schematic files for FPGA, PSU, MCU and DAC can be opened directly or via the GuitarZero.sch file.

Board: 6 copper layers, 160.4 x 102.9 mm, 145 parts (84 on the bottom side), 138 nets.

Parts:
C1, C9, C18, C54, C58, C61, C64, C65, C66, C67: 10u; C_0805_2012Metric
C2, C5, C10, C11, C15, C19, C52, C53, C55, C57, C59, C60, C72: 100n; C_0805_2012Metric
C3, C35, C70: 100u; C_0805_2012Metric
C4, C14, C56, C71: 1u; C_0805_2012Metric
C6, C7, C12, C13, C16, C17, C73: 22u; C_0805_2012Metric
C8: 3.3n; C_0805_2012Metric
C20: 330u; CAPMP7.6X4.3_1.9N_KEM
C21, C22, C23, C24, C25, C26, C39, C40, C46, C47: 4.7u; C_0805_2012Metric
C27, C28, C29, C30, C31, C32, C33, C34, C36, C37, C41, C42, C43, C48, C49, C50, C51: 0.47u; C_0603_1608Metric
C38, C44, C45: 47u; C_0805_2012Metric
C62, C63, C68, C69: 10n; C_0805_2012Metric
D1, D2, D4: LED; LED_1812_4532Metric
FB1, FB3: FerriteBead; L_0603_1608Metric
H-2023 Gruppe 3: LOGO; Guitar_Zero_Logo
J1: USB_A; USB_A_Stewart_SS-52100-001_Horizontal
J2: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal
J3: AudioJack3_SwitchT; Jack_3.5mm_CUI_SJ-3524-SMT_Horizontal
J4: MCU_Debug; PinSocket_2x10_P1.27mm_Vertical
J6: Micro_SD_Card_Det_Hirose_DM3AT; microSD_HC_Hirose_DM3BT-DSF-PEJS
L1, L2: 1.5u; L_0805_2012Metric
L3: 2.2u; L_0805_2012Metric
LS1: Speaker; R_2010_5025Metric
R1, R2: 100k; R_0805_2012Metric
R3: 6.81k; R_0805_2012Metric
R4, R6, R8: 22.1k; R_0805_2012Metric
R5: 30.1k; R_0805_2012Metric
R7: 73.2k; R_0805_2012Metric
R9: 1; R_0805_2012Metric
R10: 2.4k; R_0805_2012Metric
R11, R12, R15, R16: 4.7k; R_0805_2012Metric
R13, R14: 10k; R_0805_2012Metric
R17, R34, R35, R37: 330; R_0805_2012Metric
R18, R21, R22, R23, R24: 100; R_0805_2012Metric
R19, R20: 15; R_0805_2012Metric
R25, R26, R27, R28, R29, R30, R31: 22; R_0805_2012Metric
R32, R33: 47k; R_0805_2012Metric
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push; SW_CW_GPTS203211B
U1: TPS54325; TSSOP-14-1EP_4.4x5mm_P0.65mm
U2: TSP54294; HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3x3mm
U3: XC7A100T-FTG256; Xilinx_FTG256
U4: EFM32GG332; TQFP-64_10x10mm_P0.5mm
U5: S25FL127S; SOIC-8W_5.3x5.3mm_P1.27mm
U6: Oscillator; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm_HandSoldering
U7: FPGA_JTAG_Debug; PinSocket_2x07_P2.00mm_Vertical
U8: PCM1754; SOP63P599X175-16N
U9: TPD_Current_Switch; SOT95P280X145-6N
U10: FPGA_GPIO_Extra; PinHeader_2x09_P2.54mm_Vertical
U11, U13: 5x7 LED_matrix; LED_TA20-11SRWA
U12: MCU_GPIO_Extra; PinHeader_2x04_P2.54mm_Vertical
U14: Power_Jumpers; PinHeader_2x05_P2.54mm_Vertical
Y1: Crystal_GND23; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm

Connections:
+1V0: C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, U3.E10 (VCCBRAM), U3.F7 (VCCINT), U3.F9 (VCCINT), U3.F11 (VCCBRAM), U3.G6 (VCCINT), U3.H9 (VCCINT), U3.J6 (VCCINT), U3.K9 (VCCINT), U3.L8 (VCCINT), U14.3 (1V_Out)
+1V8: C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, U3.G8 (VCCADC_0), U3.G10 (VCCAUX), U3.J10 (VCCAUX), U3.K11 (VCCAUX), U3.L10 (VCCAUX), U14.5 (1V8_Out)
+3.3V: C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C57.1, C58.1, C59.1, C60.1, C71.1, C72.1, C73.1, D4.2 (A), J4.1 (VTARGET), J6.4 (VDD), R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R32.2, R33.2, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, U3.E7 (CFGBVS_0), U3.L6 (VCCO_0), U3.L16 (VCCO_14), U3.M9 (M0_0), U3.M13 (VCCO_14), U3.N10 (VCCO_14), U3.P7 (VCCO_14), U3.R14 (VCCO_14), U3.T11 (VCCO_14), U4.7 (IOVDD_0), U4.26 (IOVDD_3), U4.39 (VDD_DREG), U4.45 (USB_VREGI), U4.46 (USB_VREGO), U4.55 (IOVDD_5), U5.8 (VCC), U6.1 (E/D), U6.4 (VCC), U7.2 (VREF), U10.18 (Vcc), U12.8 (Vcc), U14.7 (3.3V_Out)
+3.3VA: C61.2, C62.2, C63.2, U4.23 (AVDD_1), U4.27 (AVDD_0), U14.9 (3.3VA_Out)
+5V: C1.1, C2.1, C3.1, C9.1, C10.1, C18.1, C19.1, C65.1, J2.1 (VBUS), U1.7 (EN), U1.13 (VIN), U1.14 (VCC), U2.1 (VIN1), U2.16 (VIN2), U8.6 (VCC), U9.3 (IN)
/DAC/BIT_CLOCK: R25.1, U3.P16 (IO_L8N_T1_D12_14)
/DAC/DATA_INN: R26.1, U3.M16 (IO_L7P_T1_D09_14)
/DAC/LEFT_RIGHT_CLOCK: R27.1, U3.N16 (IO_L7N_T1_D10_14)
/DAC/OUT_LEFT: C66.2, J3.T
/DAC/OUT_RIGHT: C67.2, J3.R
/DAC/SYSTEM_CLOCK_INPUT: R28.2, U3.P15 (IO_L8P_T1_D11_14)
/FPGA/Done: R17.1, U3.H10 (DONE_0), U4.53 (PF12)
/FPGA/MCU_SPI_CLCK: U3.L14 (IO_L4P_T0_D04_14), U4.42 (PC9)
/FPGA/MCU_SPI_MISO: U3.K13 (IO_L5P_T0_D06_14), U4.44 (PC11)
/FPGA/MCU_SPI_MOSI: U3.M14 (IO_L4N_T0_D05_14), U4.43 (PC10)
/FPGA/MCU_SPI_Select: U3.L13 (IO_L5N_T0_D07_14), U4.41 (PC8)
/FPGA/program_b: R16.1, U3.L9 (PROGRAM_B_0), U4.57 (PE8)
/MCU/Button 1: SW1.2, U4.10 (PC1)
/MCU/Button 2: SW2.2, U4.11 (PC2)
/MCU/Button 3: SW3.2, U4.12 (PC3)
/MCU/Button 4: SW4.2, U4.13 (PC4)
/MCU/Button 5: SW5.2, U4.14 (PC5)
/MCU/Button 6: SW6.2, U4.15 (PB7)
/MCU/USB_DM: R20.2, U4.47 (PF10)
/MCU/USB_DP: R19.2, U4.48 (PF11)
/MCU/USB_VBUS: FB3.1, U4.52 (USB_VBUS), U9.4 (OUT)
/MCU/USB_VBUSEN: U4.54 (PF5), U9.1 (EN)
/PSU/+1V0: C6.1, C7.1, L1.2, R3.2, U1.1 (VO), U14.4 (1V_In)
/PSU/+1V8: C12.1, C13.1, L2.1, R5.2, U14.6 (1V8_In)
/PSU/+3.3V: C16.1, C17.1, FB1.1, L3.2, R7.2, U14.8 (3.3V_In)
/PSU/+3.3VA: R9.1, U14.10 (3.3VA_In)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.1, C62.1, C63.1, C64.2, C65.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, J1.4 (GND), J1.5 (Shield), J2.5 (GND), J2.6 (Shield), J3.S, J4.3 (GND), J4.5 (GND), J4.9 (CD(GND)), J4.15 (GND), J4.17 (GND), J4.19 (GND), J6.6 (VSS), J6.11 (SHIELD)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
unnamed: D1.2 (A), U3.T14 (IO_L10P_T1_D14_14)
unnamed: D1.1 (K), R34.2
unnamed: D2.2 (A), U3.T15 (IO_L10N_T1_D15_14)
unnamed: D2.1 (K), R35.2
unnamed: D4.1 (K), R37.2
unnamed: FB1.2, R9.2
unnamed: J1.3 (D+), R19.1, U9.6 (D2)
unnamed: J1.2 (D-), R20.1, U9.5 (D1)
unnamed: C70.1, FB3.2, J1.1 (VBUS)
unnamed: J3.TN, LS1.2
unnamed: J4.10 (RESET), U4.20 (RESETn)
unnamed: J4.4 (SWCLK), U4.49 (PF0)
unnamed: J4.2 (SWDIO), U4.50 (PF1)
unnamed: J4.6 (SWO), U4.51 (PF2)
unnamed: J4.8 (TDI), U4.32 (PD4)
unnamed: J6.5 (CLK), R30.1
unnamed: J6.3 (CMD), R31.1
unnamed: J6.7 (DAT0), R29.1
unnamed: J6.8 (DAT1), R33.1
unnamed: J6.1 (DAT2), R32.1
unnamed: J6.2 (DAT3/CD), U4.31 (PD3)
unnamed: R22.1, U11.4 (R3), U11.11 (R3), U13.11 (R3)
unnamed: R1.2, U1.6 (PG), U2.5 (EN1)
unnamed: C8.1, U1.4 (SS)
unnamed: C5.1, L1.1, U1.10 (SW1), U1.11 (SW2)
unnamed: C5.2, U1.12 (VBST)
unnamed: R3.1, R4.2, U1.2 (VFB)
unnamed: C4.1, R1.1, U1.3 (VREG5)
unnamed: C14.2, R2.1, U2.6 (PG1), U2.12 (EN2)
unnamed: C11.2, L2.2, U2.3 (SW1)
unnamed: C15.2, L3.1, U2.14 (SW2)
unnamed: C11.1, U2.2 (VBST1)
unnamed: C15.1, U2.15 (VBST2)
unnamed: R5.1, R6.2, U2.7 (VFB1)
unnamed: R7.1, R8.2, U2.10 (VFB2)
unnamed: C14.1, R2.2, U2.9 (VREG5)
unnamed: U3.J14 (IO_L1N_T0_D01_DIN_14), U5.2 (DQ1)
unnamed: U3.J13 (IO_L1P_T0_D00_MOSI_14), U5.5 (DQ0)
unnamed: R12.1, U3.K16 (IO_L2N_T0_D03_14), U5.7 (HOLD#/DQ3)
unnamed: R11.1, U3.K15 (IO_L2P_T0_D02_14), U5.3 (W#/Vpp/DQ2)
unnamed: R10.1, U3.L12 (IO_L6P_T0_FCS_B_14), U5.1 (S#)
unnamed: U3.N11 (IO_L13P_T2_MRCC_14), U6.3 (OUTPUT)
unnamed: U3.E8 (CCLK_0), U5.6 (C)
unnamed: R15.1, U3.K10 (INIT_B_0)
unnamed: R14.1, U3.L7 (TCK_0), U7.6 (TCK)
unnamed: U3.N7 (TDI_0), U7.10 (TDI)
unnamed: U3.N8 (TDO_0), U7.8 (TDO)
unnamed: R13.1, U3.M7 (TMS_0), U7.4 (TMS)
unnamed: C56.1, U4.40 (DECOUPLE)
unnamed: U4.4 (PA3), U13.12 (C4)
unnamed: R21.2, U4.17 (PA8)
unnamed: R22.2, U4.18 (PA9)
unnamed: R23.2, U4.19 (PA10)
unnamed: R18.2, U4.16 (PB8)
unnamed: R24.2, U4.21 (PB11)
unnamed: C69.1, U4.24 (PB13), Y1.1
unnamed: C68.1, U4.25 (PB14), Y1.4
unnamed: R31.2, U4.28 (PD0)
unnamed: R29.2, U4.29 (PD1)
unnamed: R30.2, U4.30 (PD2)
unnamed: U4.60 (PE11), U11.12 (C4)
unnamed: R25.2, U8.1 (BCK)
unnamed: R26.2, U8.2 (DATA)
unnamed: R27.2, U8.3 (LRCK)
unnamed: R28.1, U8.16 (SCK)
unnamed: C64.1, U8.10 (Vcom)
unnamed: C66.1, U8.7 (VoutL)
unnamed: C67.1, U8.8 (VoutR)
unnamed: U3.P8 (IO_L20P_T3_A08_D24_14), U10.3 (GPIO_1)
unnamed: U3.R5 (IO_L23P_T3_A03_D19_14), U10.2 (GPIO_2)
unnamed: U3.N6 (IO_L19N_T3_A09_D25_VREF_14), U10.5 (GPIO_3)
unnamed: U3.T5 (IO_L23N_T3_A02_D18_14), U10.4 (GPIO_4)
unnamed: U3.M6 (IO_L19P_T3_A10_D26_14), U10.7 (GPIO_5)
unnamed: U3.R6 (IO_L24P_T3_A01_D17_14), U10.6 (GPIO_6)
unnamed: U3.P9 (IO_L18N_T2_A11_D27_14), U10.9 (GPIO_7)
unnamed: U3.R7 (IO_L24N_T3_A00_D16_14), U10.8 (GPIO_8)
unnamed: U3.N9 (IO_L18P_T2_A12_D28_14), U10.11 (GPIO_9)
unnamed: U3.R8 (IO_L20N_T3_A07_D23_14), U10.10 (GPIO_10)
unnamed: U3.R11 (IO_L17N_T2_A13_D29_14), U10.13 (GPIO_11)
unnamed: U3.T8 (IO_L21N_T3_DQS_A06_D22_14), U10.12 (GPIO_12)
unnamed: U3.R10 (IO_L17P_T2_A14_D30_14), U10.15 (GPIO_13)
unnamed: U3.T9 (IO_L22P_T3_A05_D21_14), U10.14 (GPIO_14)
unnamed: U3.T13 (IO_L16N_T2_A15_D31_14), U10.17 (GPIO_15)
unnamed: U3.T10 (IO_L22N_T3_A04_D20_14), U10.16 (GPIO_16)
unnamed: U4.63 (PE14), U11.2 (C1)
unnamed: U4.64 (PE15), U11.7 (C2)
unnamed: U4.62 (PE13), U11.1 (C3)
unnamed: U4.58 (PE9), U11.8 (C5)
unnamed: U4.61 (PE12), U11.14 (C6)
unnamed: U4.59 (PE10), U11.9 (C7)
unnamed: R21.1, U11.6 (R1), U13.6 (R1)
unnamed: R18.1, U11.10 (R2), U13.10 (R2)
unnamed: R24.1, U11.3 (R4), U13.3 (R4)
unnamed: R23.1, U11.13 (R5), U13.13 (R5)
unnamed: U4.35 (PD7), U12.3 (GPIO_1)
unnamed: U4.37 (PC6), U12.2 (GPIO_2)
unnamed: U4.34 (PD6), U12.5 (GPIO_3)
unnamed: U4.38 (PC7), U12.4 (GPIO_4)
unnamed: U4.33 (PD5), U12.7 (GPIO_5)
unnamed: U4.36 (PD8), U12.6 (GPIO_6)
unnamed: U4.6 (PA5), U13.2 (C1)
unnamed: U4.9 (PC0), U13.7 (C2)
unnamed: U4.5 (PA4), U13.1 (C3)
unnamed: U4.3 (PA2), U13.8 (C5)
unnamed: U4.1 (PA0), U13.14 (C6)
unnamed: U4.2 (PA1), U13.9 (C7)

## Commit log

2023-09-07 inital verilog sound demo
2023-09-07 cooler demo song 🤯
2023-09-20 multiple working generators
2023-09-20 working kbd_hid example
2023-09-20 project exports
2023-09-20 Update readme.md with the dings
2023-09-21 working multi channel mixer
2023-09-22 working sine with lut
2023-09-22 updated sine explanation
2023-09-22 small cleanup
2023-09-27 working multi_channel_mixer
2023-09-29 multi channel mixer max value bug
2023-09-30 finally working amplitude modulator
2023-09-30 refactor try 1
2023-09-30 discovered pausing the sounds
2023-10-02 working ewma filter
2023-10-02 non working ADSR
2023-10-03 kinda working adsr i guess
2023-10-03 move adsr input to voice
2023-10-03 fixed dout to not cut out adsr r part, cooler demo
2023-10-06 ultimate jank reverb
2023-10-06 At least the simulation runs a bit faster now
2023-10-06 fix disabled reverb
2023-10-10 renamed files
2023-10-10 oops, delete all vh files
2023-10-10 simplified a bit by removing variable bit lengths
2023-10-10 removed sound_valid
2023-10-13 Make simulation work on new machine
2023-10-17 adds gitignore
2023-10-17 Removes simplicity studio files
2023-10-17 adds cmake files and gecko sdk copies
2023-10-17 removes excess build files
2023-10-18 fixes cmake config, the project compiles!
2023-10-18 readme med guide
2023-10-20 multiple instruments test, fixed high notes
2023-10-20 demo instrument with multiple voices
2023-10-25 Decrease needed cmake version and add first price env
2023-10-27 Legg inn det jeg jobbet med før vi fikk opp commander
2023-10-29 Lag program for å generere sanger fra midi-filer
2023-10-30 Lag funksjoner for å displaye banen på led-matrisen
2023-10-31 implements basic spi support
2023-10-31 lineend printf
2023-11-01 cleanup spi impl
2023-11-08 Lag FPGA Test
2023-11-10 Send konstant 0b1111111111111111 på SPI
2023-11-13 Playing All Star
2023-11-15 Add test song
2023-11-16 Make notes sticky in array
2023-11-16 Max notes 8
2023-11-16 feat: enables linking of project to simplicity studio to create two environments for building
2023-11-16 fix: timer config and sl_sleep_manager beeing turned on (not good)
2023-11-16 feat: updates to render level in fpga test
2023-11-16 fix: wierd include error in cmake project
2023-11-17 add note freq generating script
2023-11-17 Add song name and prefix
2023-11-18 Support playing multiple songs
2023-11-18 Actually send empty notes
2023-11-18 undertale2
2023-11-18 Throuhg the fire and flames
2023-11-18 Display Text
2023-11-20 Buttons made
2023-11-20 Make scene manager and prepare menu
2023-11-20 Add lead to miniMIDI
2023-11-20 Add Verilog sources and Vivado project
2023-11-20 Menu fix
2023-11-20 Fix send_empty
2023-11-20 feat: adds controls vars and functions for reading button inputs
2023-11-20 feat: adds controls and game logic, pog
2023-11-21 adds preview of song in menu
2023-11-21 Remove old songs, add Eye of the tiger
2023-11-21 Kickstart my heart
2023-11-21 Make eye of the tiger easier
2023-11-21 Bjørnen sover
2023-11-21 supermario
2023-11-21 Improve eye of the Tiger
2023-11-21 Improve kickstart my heart
2023-11-21 Add megalovania
2023-11-21 smaller attack on two instruments, remove empty output
2023-11-21 Add through the fire and flames
2023-11-21 feat: adds end of song check
2023-11-21 supermario midi
2023-11-21 feat: adds feedback to correctly played notes
2023-11-21 feat: padding start of megalovania
2023-11-21 Add hold for reset + crocketts theme
2023-11-22 adds mcu project in repo pog
2023-11-22 fixes some not moved files
2023-11-22 move fpga files into fpga folder
2023-11-22 Add root README
2023-11-22 Add PCB contents
2023-11-22 rename
2023-11-22 rename part 2
2023-11-22 move note freq module file
2023-11-22 Update sine_lut.mem comment
